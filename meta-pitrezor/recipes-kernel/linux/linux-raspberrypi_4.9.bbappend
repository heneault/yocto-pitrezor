FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://usb_inode.patch"
