EXTRA_OECONF += " --enable-video-fbcon "

