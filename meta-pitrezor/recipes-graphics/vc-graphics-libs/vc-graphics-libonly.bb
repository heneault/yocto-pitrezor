CONFLICTS = "vc-graphics-hardfp-libonly"

VCDIR = "opt/vc"
require vc-graphics-libonly.inc

PR = "${INCPR}.0"
