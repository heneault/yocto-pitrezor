CONFLICTS = "vc-graphics-libonly"

VCDIR = "hardfp/opt/vc"
require vc-graphics-libonly.inc

PR = "${INCPR}.0"
