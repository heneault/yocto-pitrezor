FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://fix_i2c_core_clock.patch"
