SRC_URI = "git://github.com/google/protobuf.git;tag=v3.4.1"
SRCREV = ""

