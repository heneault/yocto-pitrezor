PACKAGECONFIG_remove = "sdl"
